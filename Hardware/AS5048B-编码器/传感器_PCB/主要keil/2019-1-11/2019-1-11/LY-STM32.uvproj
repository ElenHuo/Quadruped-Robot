# Keil uVision project LY-STM32.uvproj, settings and files
target LY-STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LY-STM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c I2C.c AT24Cxx.c sys.c as5048b.c pd.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
